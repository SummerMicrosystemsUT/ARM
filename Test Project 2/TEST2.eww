<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\Project #0\Project #0.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TestProject2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


